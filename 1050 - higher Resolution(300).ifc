Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_2/temp/tmp_392_25_c1EGG/format_0/1050 - higher Resolution(300).ifc
Time: 2023-02-23T10:30:19
Made in: PARTsolutions

# IfcProject, 1050 - higher Resolution(300)
Description: MEISTERSTÜCK OYO DUO

# IfcDiscreteAccessory, 1050 - higher Resolution(300)
In: BUILDING
Description: 1050 - higher Resolution(300)
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 1050
ePset_PARTsolutions - NB: 1050 - higher Resolution(300); NN: 1050 higher resolution; NT: MEISTERSTÜCK OYO DUO; NBSYN: $MNR. - higher Resolution($LODLEVEL.); LINA: 1050 - higher Resolution(300); CATALOG: Kaldewei; MNR: 1050; LODLEVEL: 300; B: oyo_duo_1630x770x580.png; C: MEISTERSTÜCK OYO DUO; D: 0.0; E: KALDEWEI; F: -; H: WEB info; I: PDF info; J: -; K: -; L: -; M: -; N: -; O: -; P: -; Q: -; R: -; S: EC003246; EF002169: enamelled steel (EV000166; EV002029); EF000051: Oval (EV000396); EF000007: alpine white (EV000202); EF000049: 770; EF004567: 1630; EF000040: 580
